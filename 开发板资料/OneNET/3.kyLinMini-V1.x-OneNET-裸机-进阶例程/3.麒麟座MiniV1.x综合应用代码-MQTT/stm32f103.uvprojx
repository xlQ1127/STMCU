# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\framework
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_md.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c
  group hardware
    ./hardware/src/: at24c02.c delay.c i2c.c led.c sht20.c usart.c hwtimer.c selfcheck.c rtc.c
  group user
    ./user/: main.c dataStreamName.h
  group OneNET
    ./NET/onenet/src/: onenet.c fault.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c dStream.c
  group net_device
    ./NET/device/src/: net_io.c net_device.c
  group framework
    ./framework/: framework.c
software components: CMSIS:CORE 4.3.0
