<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NRF24L01_RX.ewp</path>
  </project>
  <batchBuild />
</workspace>
