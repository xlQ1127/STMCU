# Keil uVision project SmartHouse.uvprojx, settings and files
target SmartHouse (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartHouse
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\EDP;..\Driver;..\Network;..\USER;..\Libraries\CMSIS;..\Libraries\CMSIS\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_rcc.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group HAL
    ../Driver/: delay.c i2c.c led.c sht20.c usart1.c usart2.c house.c rc522_config.c rc522_function.c
  group NETWORK
    ../Network/: esp8266.c
  group EDP
    ../EDP/: cJSON.c EdpKit.c utils.c EdpDemo.c
