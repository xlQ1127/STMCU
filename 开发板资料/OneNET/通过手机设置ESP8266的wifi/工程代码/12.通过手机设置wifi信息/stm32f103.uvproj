# Keil uVision project stm32f103.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\sys;.\hardware\inc;.\EDP;.\UCOSII\CONFIG;.\UCOSII\PORT;.\UCOSII\CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group sys
    ./sys/: stm32f10x_it.c
  group core
    ./core/: core_cm3.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group ucos_CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos_PORT
    ./UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group ucos_CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_flash.c
  group hardware
    ./hardware/src/: led.c delay.c key.c lcd1602.c esp8266.c usart.c timer.c adxl345.c i2c.c sht20.c global.c onenet.c iwdg.c gy30.c m6311.c stmflash.c
  group user
    ./user/: main.c
  group EDP
    ./EDP/: cJSON.c EdpKit.c
