# IAR project STemwin_1p8_TFT.ewp, settings and files
configuration STemwin_1p8_TFT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; E:\STM32F103C8T6\STemwin_1p8_TFT\STemwin\Config; E:\STM32F103C8T6\STemwin_1p8_TFT\STemwin\inc; E:\STM32F103C8T6\STemwin_1p8_TFT\BSP
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STemwin_1p8_TFT.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group BSP
    ../BSP/: arm_cortexM3l_math.lib BSP_Button.c BSP_GPS.c BSP_LCD.c MyFont13.c MyFont24.c MyFont33.c WindowDLG.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_iwdg.c
  group STemiwn
    ../STemwin/Config/: GUI_X.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c STemWin532_CM3_Keil.lib
