# Keil uVision project Temp.uvproj, settings and files
target Temp (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Temp +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\Project;..\USER\ADC;..\USER\bmp180;..\USER\CONTROL;..\USER\IMU;..\USER\LED;..\USER\MPU6050;..\USER\NRF24L01;..\USER\SysTick;..\USER\TIM3_IT;..\USER\TIM4_PWM;..\USER\USART1;..\USER\IIC_IO;..\USER\SPI_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group HARDWARE
    ../USER/TIM3_IT/: TIM3_IT.c
    ../USER/SysTick/: SysTick.c
    ../USER/LED/: led.c
    ../USER/ADC/: adc.c
    ../USER/USART1/: usart.c
    ../USER/SPI_IO/: SPI_IO.c
    ../USER/NRF24L01/: NRF24L01.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group DOC
    ../DOC/: readme.txt
