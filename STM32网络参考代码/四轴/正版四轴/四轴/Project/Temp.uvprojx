# Keil uVision project Temp.uvprojx, settings and files
target Temp (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temp
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\USER;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\Project;..\USER\ADC;..\USER\bmp180;..\USER\CONTROL;..\USER\IMU;..\USER\LED;..\USER\MPU6050;..\USER\NRF24L01;..\USER\SysTick;..\USER\TIM3_IT;..\USER\TIM4_PWM;..\USER\USART1;..\USER\IIC_IO;..\USER\SPI_IO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group HARDWARE
    ../USER/TIM3_IT/: TIM3_IT.c
    ../USER/SysTick/: SysTick.c
    ../USER/LED/: led.c
    ../USER/ADC/: adc.c
    ../USER/USART1/: usart.c
    ../USER/IIC_IO/: IIC.c
    ../USER/MPU6050/: MPU6050.c
    ../USER/IMU/: imu.C
    ../USER/SPI_IO/: SPI_IO.c
    ../USER/NRF24L01/: NRF24L01.c
    ../USER/TIM4_PWM/: TIM4_PWM.c
    ../USER/CONTROL/: control.C
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group DOC
    ../DOC/: readme.txt
software components: CMSIS:CORE 5.1.1
