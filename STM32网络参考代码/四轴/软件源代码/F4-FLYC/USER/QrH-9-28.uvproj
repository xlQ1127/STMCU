# Keil uVision project QrH-9-28.uvproj, settings and files
target QrH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: QrH-9-28
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\CMSIS;..\FWlib\Include;..\SOURECE\inc;..\FWlib\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f4xx.s
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c
  group SOURCE
    ../SOURECE/src/: delay.c led.c main.c pwm_in.c pwm_output.c stm32f4xx_it.c timer.c usart.c IIC.c MPU6050.c IMU.c control.c
