# Keil uVision project AutoQuadrotor.uvprojx, settings and files
target UAV_V1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AutoQuadrotor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --CPP
  c include: .\1.code\dev;.\2.prject\F407LIB;.\2.prject\F407LIB\inc;.\1.code\uav;.\1.code;.\3.math;.\3.math\adrc\codegen\lib\fal;.\1.code\navigation;.\1.code\navigation\height;.\1.code\navigation\height\codegen\lib\nav_h_ekf;.\1.code\attitude;.\1.code\attitude\ekf;.\1.code\attitude\ekf\codegen;.\2.prject\FATFS\src;.\3.math\adrc;.\1.code\control;.\1.code\px4\ekf_att_pos_estimator;.\1.code\px4\geo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./1.code/: uav_task.cpp includes.h
    ./1.code/uav/: uav_control.cpp uav_adrc.cpp uav_pid.cpp uav_init.cpp uav_filter.cpp uav_rc.cpp uav_parameter.cpp uav_parameter_sd.cpp
  group px4/ekf
    ./1.code/px4/ekf_att_pos_estimator/: ekf_att_pos_estimator_main.cpp estimator_22states.cpp estimator_utilities.cpp
  group attitude
    ./1.code/attitude/: imu.cpp imu_dcm.cpp imu_gradient.cpp imu_ekf.cpp
  group attitude/ekf
    ./1.code/attitude/ekf/codegen/: AttitudeEKF.c AttitudeEKF.h
  group navigation
    ./1.code/uav/: uav_attitude.cpp uav_gps_navigation.cpp
    ./1.code/navigation/: nav_ekf.cpp nav_speed.cpp
  group navigation/heigth
    ./1.code/navigation/height/: nav_h.cpp
    ./1.code/navigation/height/codegen/lib/nav_h_ekf/: nav_h_ekf.c nav_h_ekf_initialize.c nav_h_ekf_terminate.c svd.c
  group dev
    ./1.code/dev/: dev_rcc.cpp dev_i2c.cpp dev_led.cpp dev_port.cpp dev_moto.cpp dev_nvic.cpp dev_usart.cpp dev_debus.cpp dev_clock.cpp dev_ak8975.cpp dev_mavlink.cpp dev_ms5611.cpp dev_sd.cpp dev_mup6050.cpp dev_spi.cpp dev_flash.cpp dev_dma.cpp dev_us100.cpp dev_gps.cpp dev_can.cpp
  group math
    ./3.math/: cal_math.cpp cal_matrix3.cpp cal_vector3.cpp cal_quaternion.cpp
  group math/adrc
    ./3.math/adrc/: cal_adrc.cpp
    ./3.math/adrc/codegen/lib/fal/: fhan.c fal.c fal_initialize.c fal_terminate.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
  group lib
    ./2.prject/F407LIB/: F407lib.lib stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ./2.prject/FATFS/src/: diskio.c ff.c
  group note
    ./2.prject/note/: log.txt readme.txt
  group control
    ./1.code/control/: control_v.cpp
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1
