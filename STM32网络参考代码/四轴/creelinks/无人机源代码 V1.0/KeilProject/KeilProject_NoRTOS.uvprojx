# Keil uVision project KeilProject_NoRTOS.uvprojx, settings and files
target STM32F103x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KeilProject_NoRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ModuleLib;..\StandardLib;..\UserCode;..\Stm32f10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Stm32f10x
    ../Stm32f10x/: core_cm3.c core_cm3.h misc.c misc.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h system_stm32f10x.c system_stm32f10x.h
  group StandardLib
    ../StandardLib/: CeAd.c CeAd.h CeCcp.c CeCcp.h CeDa.c CeDa.h CeDebug.c CeDebug.h CeExtra.c CeExtra.h CeFlash.c CeFlash.h CeGpio.c CeGpio.h CeI2c.c CeI2c.h CeInt.c CeInt.h CeMcu.h CePwm.c CePwm.h CeSpi.c CeSpi.h CeSystem.c CeSystem.h CeTask.c CeTask.h CeTicker.c CeTicker.h CeTimer.c CeTimer.h CeUart.c CeUart.h Creelinks.h
  group ModuleLib
    ../ModuleLib/: Ce6Dof.c Ce6Dof.h CeBeepNSrc.c CeBeepNSrc.h CeBlueHc.c CeBlueHc.h CeBmp180.c CeBmp180.h CeBtnx1.c CeBtnx1.h CeLed1C.c CeLed1C.h CePC33V.c CePC33V.h CeWifiEsp.c CeWifiEsp.h CeWlsNrf.c CeWlsNrf.h
  group UserCode
    ../UserCode/: CeTMU.h CeTMU.c CePID.h CePID.c CePackage.h CePackage.c CeMD.h CeMD.c CeLedCtl.h CeLedCtl.c CeFilter.h CeFilter.c
    ./: main.c
