# IAR project Project-STM32L4xx-Nucleo.ewp, settings and files
configuration Project-STM32L4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; USE_STM32L4XX_NUCLEO; USE_FREE_RTOS
  ICCARM.CCIncludePath2: ../../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/TeseoIII; ../../../../../../Drivers/BSP/STM32L4xx_Nucleo; ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1; ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Inc; ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Inc; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Inc
  OBJCOPY.OOCOutputFile: Project-STM32L4xx-Nucleo.bin
  ILINK.IlinkOutputFile: Project-STM32L4xx-Nucleo.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../Src/: config_bus.c gnss_data_if.c gnss_utils.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/BSP/Components/TeseoIII
    ../../../../../../Drivers/BSP/Components/TeseoIII/: teseo_i2c.c teseo_io.c teseo_queue.c teseo_uart.c
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-GNSS1A1
    ../../../../../../Drivers/BSP/X-NUCLEO-GNSS1A1/: gnss_fw_upgrade.c x_nucleo_gnss1a1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/ST/STM32_GNSS/LibGNSS
    ../../../../../../Middlewares/ST/STM32_GNSS/LibGNSS/Src/: gnss_parser.c
  group Middlewares/ST/STM32_GNSS/LibNMEA
    ../../../../../../Middlewares/ST/STM32_GNSS/LibNMEA/Src/: NMEA_parser.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
