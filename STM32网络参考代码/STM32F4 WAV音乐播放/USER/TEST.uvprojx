# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\NRF24L01;..\HARDWARE\SD;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\PS2;..\TEXT;..\FAT;..\SYSFILE;..\JPEG;..\HARDWARE\FSMC;..\HARDWARE\DAC;..\WAV
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/FSMC/: fsmc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/TIMER/: timer.c
  group FAT
    ../FAT/: FAT.C
  group SYSFILE
    ../SYSFILE/: sysfile.c
  group WAV
    ../WAV/: wavplay.c
software components: CMSIS:CORE 5.1.2
