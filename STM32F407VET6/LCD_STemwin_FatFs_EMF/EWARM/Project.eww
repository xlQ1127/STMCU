<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LCD_STemwin_FatFs_EMF.ewp</path>
  </project>
  <batchBuild />
</workspace>
