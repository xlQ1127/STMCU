# Keil uVision project STemwin_1p8_TFT.uvprojx, settings and files
target STemwin_1p8_TFT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STemwin_1p8_TFT
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ../Inc;                            ../Drivers/STM32F1xx_HAL_Driver/Inc;                            ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                            ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                            ../Drivers/CMSIS/Include;                            ..\STemwin\Config;                            ..\STemwin\inc;                            ..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../BSP/: WindowDLG.c
  group STemwin
    ../STemwin/Config/: GUI_X.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c STemWin532_CM3_Keil.lib
  group BSP
    ../BSP/: BSP_Button.c BSP_GPS.c BSP_LCD.c MyFont13.c MyFont33.c MyFont24.c arm_cortexM3l_math.lib BSP_LED.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.2
