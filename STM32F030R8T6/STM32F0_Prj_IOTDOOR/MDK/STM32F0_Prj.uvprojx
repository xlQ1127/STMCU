# Keil uVision project STM32F0_Prj.uvprojx, settings and files
target STM32F0_Prj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0_Prj
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWlib\inc;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\CMSIS\DeviceSupport\arm;..\user\inc;..\mcu_sdk
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/src/: common.c FaceReco.c isr.c main.c GPIO_Init.c motor.c systemstatus.c wtn6040.c
  group lib
    ../FWlib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group WIFI_SDK
    ../mcu_sdk/: mcu_api.c protocol.c system.c
  group Start_up
    ../CMSIS/DeviceSupport/arm/: startup_stm32f030.s
    ../CMSIS/DeviceSupport/: system_stm32f0xx.c
