# IAR project Project.ewp, settings and files
configuration STM32072B_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F072xB; USE_HAL_DRIVER; USE_STM32072B_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Devices\ST\STM32F0xx\Include; ..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32072B_EVAL; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: F0source.bin
  ILINK.IlinkOutputFile: STM32072B_EVAL.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L476G_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476ZG ST STM32L476ZG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L476G_EVAL_REVB; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\Drivers\CMSIS\Devices\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32L476G_EVAL; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\CMSIS\Include
  OBJCOPY.OOCOutputFile: L4source.bin
  ILINK.IlinkOutputFile: STM32L476G_EVAL.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM32072B_EVAL
    ../../../Drivers/BSP/STM32072B_EVAL/: stm32072b_eval.c stm32072b_eval_lcd.c stm32072b_eval_sd.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval.c stm32l476g_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c system_stm32l4xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32f072xb.s startup_stm32l476xx.s
  group Example/User
    ../Src/: main.c stm32f0xx_it.c stm32l4xx_it.c
