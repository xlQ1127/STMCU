# Keil uVision project RagingFire_Fly.uvprojx, settings and files
target RagingFire_Fly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RagingFire_Fly
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User\APP;..\User\BSP;..\Library\CMSIS\CM3\CoreSupport;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group System
    ../User/APP/: main.c stm32f10x_it.c system_stm32f10x.c
  group User_APP
    ../User/APP/: IMU.c Filter.c Tasks.c Maths.c Control.c Protocol.c
  group User_BSP
    ../User/BSP/: Led.c Uart.c Motor.c Timer3.c EEPROM.c Struct_All.c DMA_ADC.c I2C_MPU6050.c SPI_NRF24L01.c
  group Library
    ../Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.1.1
