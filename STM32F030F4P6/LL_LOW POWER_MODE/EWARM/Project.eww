<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LL_LOW_POWER_MODE.ewp</path>
  </project>
  <batchBuild />
</workspace>
