# Keil uVision project ANO_FLY.uvprojx, settings and files
target ANO_FLY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ANO_FLY
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\LIB;.\APP;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYS
    ./APP/: main.c stm32f10x_it.c sysconfig.h
  group APP
    ./APP/: Imu.c Imu.h Control.c Control.h Rc.c Rc.h Data_Transfer.c Data_Transfer.h
  group BSP
    ./BSP/: BSP.c BSP.h Led.c Led.h eeprom.c eeprom.h Tim3.c Tim3.h Usart.c Usart.h MPU6050.c MPU6050.h Moto.c Moto.h Spi.c Spi.h Nrf24l01.c Nrf24l01.h Tim_pwm_in.c Tim_pwm_in.h
  group LIB
    ./LIB/: stm32f10x_conf.h startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c
  group IICLIB
    ./BSP/: ANO_TC_STM32F1_I2C.h ANO_TC_STM32F1_I2C.lib
software components: CMSIS:CORE 5.0.2
