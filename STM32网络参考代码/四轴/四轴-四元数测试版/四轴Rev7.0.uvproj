# Keil uVision project 四轴Rev7.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 四轴Rev7.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 四轴 Rev7.0.C MPU-6050.C NRF24L01.C STC15W4KPWM.C Timer.C EEPROM.C USART.C IMU.C
